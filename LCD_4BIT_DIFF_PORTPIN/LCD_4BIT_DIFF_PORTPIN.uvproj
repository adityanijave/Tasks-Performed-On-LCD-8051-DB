# Keil uVision project LCD_4BIT_DIFF_PORTPIN.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LCD_4BIT_DIFF_PORTPIN +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 LCD_4BIT_DIFF_PORTPIN_MAIN.c delay.c delay.h
