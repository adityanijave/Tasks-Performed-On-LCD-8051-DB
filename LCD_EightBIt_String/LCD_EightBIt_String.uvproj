# Keil uVision project LCD_EightBIt_String.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: LCD_EightBIt_String +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 LCD_EightBit_String.c LCD_EightBit_String.h LCD_EightBIt_String_Main.c delay.c
